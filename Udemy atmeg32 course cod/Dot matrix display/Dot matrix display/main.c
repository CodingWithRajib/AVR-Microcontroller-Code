
#define F_CPU 8000000UL
#include <avr/io.h>
#include <util/delay.h>

char col[][8] = {
	{0x18, 0x3C, 0x66, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3},
	{0xFE, 0xC3, 0xC3, 0xFE, 0xFE, 0xC3, 0xC3, 0xFE},
	{0x3F, 0x7F, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0x3F}
	};
char row[8] = {0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xDF, 0x7F};
int main(){
	int k = 0;
	DDRC = 0xFF;
	DDRD = 0xFF;
	
	while(1){
		if(k>2) k = 0;
		
		for(int i = 0; i<300; i++){
			for(int j = 0; j<8; j++){
				PORTC = row[j];
				PORTD = col[k][j];
				_delay_ms(1);
			}
		}
		k++;
	}
	
	
}